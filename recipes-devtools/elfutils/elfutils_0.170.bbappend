
FILESEXTRAPATHS_prepend := "${THISDIR}/elfutils:"

SRC_URI += " \
    file://0001-Ensure-that-packed-structs-follow-the-gcc-memory-lay.patch \
"
