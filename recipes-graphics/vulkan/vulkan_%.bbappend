INSANE_SKIP_${PN}-bin += "build-deps file-rdeps"
